# IAR project ucosiii-f767.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F767IG ST STM32F767IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32F767xx
  ICCARM.CCIncludePath2: D:\Apollo\ucosiii; D:\Apollo\ucosiii\CMSIS_header; D:\Apollo\ucosiii\CMSIS_core; D:\Apollo\ucosiii\HAL_Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ucosiii-f767.hex
  ILINK.IlinkOutputFile: ucosiii-f767.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group CMSIS
    CMSIS_core/: startup_stm32f767xx.s system_stm32f7xx.c
  group HAL-lib
    HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_it.c
